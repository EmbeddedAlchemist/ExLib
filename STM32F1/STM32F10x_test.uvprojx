# Keil uVision project STM32F10x_test.uvprojx, settings and files
target ExLib (6190000::V6.19::ARMCLANG)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: STM32F10x_test
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\ExLib\Include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group DeviceSupport
    ./ExLib/Source/DeviceSupport/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c system_stm32f10x.c
    ./ExLib/Source/DeviceSupport/startup/arm/: startup_stm32f10x_md.s
  group ExLib
    ./ExLib/Source/: ExLib_Main.cpp ExLib_Exception.cpp ExLib_GPIO.cpp ExLib_PrintStream.cpp
  group User
    ./User/: main.cpp
